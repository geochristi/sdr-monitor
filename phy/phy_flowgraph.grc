options:
  parameters:
    category: ''
    generate_options: no_gui
    id: phy_flowgraph
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Modulation
  id: variable
  parameters:
    value: '16'
  states: {}
- name: bits_per_symbol
  id: variable
  parameters:
    value: int(math.log2(Modulation))
  states: {}
- name: mod_type
  id: variable
  parameters:
    value: '"QAM"'
  states: {}
- name: noise_voltage
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: noise_voltage
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: bits_per_symbol
    len_tag_key: packet_len
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: 0 if mod_type == "PSK" else 1
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: blocks_selector_1_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: 0 if mod_type == "PSK" else 1
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: ( digital.constellation_bpsk().base() if (mod_type == "PSK" and Modulation == 2) else digital.constellation_qpsk().base() if (mod_type == "PSK" and Modulation == 4) else digital.constellation_8psk().base() if (mod_type == "PSK" and Modulation == 8) else digital.qam_constellation(Modulation, False).base() )
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: ( digital.constellation_bpsk().base() if (mod_type == "PSK" and Modulation == 2) else digital.constellation_qpsk().base() if (mod_type == "PSK" and Modulation == 4) else digital.constellation_8psk().base() if (mod_type == "PSK" and Modulation == 8) else digital.qam_constellation(Modulation, False).base() )
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: Modulation if mod_type == "PSK" else 1
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: Modulation if mod_type == "PSK" else 1
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import json
      from time import time

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Packet Generator Block - generates PDUs with random bytes"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='packet generator',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_in(pmt.intern('trigger'))
              self.set_msg_handler(pmt.intern('trigger'), self.handle_msg)

              self.message_port_register_out(pmt.intern('out')) # packets
              self.message_port_register_out(pmt.intern('metrics')) # telemetry
             
              self.packet_id = 0

          def handle_msg(self, msg):
              length = 256

              data = np.random.randint(0, 256, length, dtype=np.uint8)

              # packet id on the first byte
              data[0] = self.packet_id % 256
              self.packet_id += 1

              pdu = pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(data), data.tolist()))

              # publish pakcet 
              self.message_port_pub(pmt.intern('out'), pdu)

              #publish telemetry
              # self.publish_metrics()



          def publish_metrics(self):
              metrics = {
                  'snr': 12.5,
                  'ber': 0.00003,
                  'rssi': -42.0,
                  # 'packet_id': self.packet_id,
                  # 'noise_voltage': noise_voltage,
                  'timestamp': time()
              }
              print("SENT:", metrics)
              msg = json.dumps(metrics).encode('utf-8')

              # send directly as u8vector (no PDU wrapper )
              u8vec = pmt.init_u8vector(len(msg), list(msg))
              self.message_port_pub(pmt.intern('metrics'), u8vec)
              # msg_list = list(msg) # convert bytes to list of integers
              # pdu = pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(msg_list), msg_list))
              # self.message_port_pub(pmt.intern('metrics'), pdu)
    example_param: '1.0'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport json\nfrom time import time\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n# BER comparator\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Compare TX/RX byte streams and publish BER metrics.\"\"\"\n\n    def __init__(self):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='ber_comparator',   # will show up in GRC\n            in_sig=[np.uint8, np.uint8],  # two input streams of bytes\n            out_sig=None\n        )\n\n        # Metrics output\n        self.message_port_register_out(pmt.intern('metrics'))\n\n        # Running totals (lifetime)\n        self.total_bits = 0\n        self.total_bit_errors = 0\n\n        # Windowed BER state\n        self.window_symbols = 0\n        self.window_errors = 0\n        self.WINDOW_SIZE = 10000\n\n\n    def work(self, input_items, output_items):\n        # Receive synchronized TX/RX streams.\n        tx = input_items[0]\n        rx = input_items[1]\n        # print(\"TX:\", tx[:10])\n        # print(\"RX:\", rx[:10])\n        n = min(len(tx), len(rx))\n        print(\"[BER] work() items:\", n)\n        if n == 0:\n            return 0\n        \n\n        # Compare only the common region if buffers differ in length.\n        tx_view = tx[:n]\n        rx_view = rx[:n]\n        bit_errors = int(np.sum(tx_view != rx_view))\n\n        # Update running totals.\n        self.total_bits += n\n        self.total_bit_errors += bit_errors\n\n        print(f\"[BER] chunk errors: {bit_errors}/{n}\")\n        print(f\"[BER] totals: bits={self.total_bits}, errors={self.total_bit_errors}\")\n        with open(\"/tmp/phy_stats.txt\", \"w\") as f:\n            f.write(f\"{self.total_bits},{self.total_bit_errors}\\n\")\n            \n        self.window_symbols += n\n        self.window_errors += bit_errors\n\n        # Publish BER once enough symbols have been collected.\n        if self.window_symbols >= self.WINDOW_SIZE:\n            ber = self.window_errors / self.window_symbols\n            \n            print(\"[BER] window ber:\", ber)\n                \n            # Send metrics as a dictionary\n            metrics = {\n                'ber': ber,\n                # 'total_bits': self.total_bits,\n                # 'error_bits': self.error_bits,\n                'timestamp': time()\n            }\n\n            msg_json = json.dumps(metrics).encode('utf-8')\n            u8vec = pmt.init_u8vector(len(msg_json), list(msg_json))\n            self.message_port_pub(pmt.intern('metrics'), u8vec)\n\n            # Reset window counters after publishing.\n            self.window_symbols = 0\n            self.window_errors = 0\n            \n        return n\n\n"
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
  states: {}
- name: zeromq_pub_msg_sink_0_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:5556
    timeout: '100'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_message_strobe_0, strobe, epy_block_0, trigger]
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_repack_bits_bb_0, '0', blocks_selector_1, '1']
- [blocks_repack_bits_bb_0, '0', digital_diff_encoder_bb_0, '0']
- [blocks_repack_bits_bb_0, '0', epy_block_1, '0']
- [blocks_selector_1, '0', digital_constellation_encoder_bc_0, '0']
- [blocks_selector_1_0, '0', epy_block_1, '1']
- [blocks_throttle2_0, '0', blocks_add_xx_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_selector_1_0, '1']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_encoder_bc_0, '0', blocks_throttle2_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_selector_1_0, '0']
- [digital_diff_encoder_bb_0, '0', blocks_selector_1, '0']
- [epy_block_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [epy_block_0, out, zeromq_pub_msg_sink_0, in]
- [epy_block_1, metrics, zeromq_pub_msg_sink_0_0, in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_repack_bits_bb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
