options:
  parameters:
    category: ''
    generate_options: qt_gui
    id: phy_flowgraph
    output_language: python
    run_command: '{python} -u run_phy.py'
    title: Not titled yet
  states: {}

blocks:
- name: Modulation
  id: variable
  parameters:
    value: '16'
  states: {}
- name: bits_per_symbol
  id: variable
  parameters:
    value: int(math.log2(Modulation))
  states: {}
- name: mod_type
  id: variable
  parameters:
    value: '"QAM"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: bits_per_symbol
    len_tag_key: packet_len
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: 0 if mod_type == "PSK" else 1
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: blocks_selector_1_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: 0 if mod_type == "PSK" else 1
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: ( digital.constellation_bpsk().base() if (mod_type == "PSK" and Modulation == 2) else digital.constellation_qpsk().base() if (mod_type == "PSK" and Modulation == 4) else digital.constellation_8psk().base() if (mod_type == "PSK" and Modulation == 8) else digital.qam_constellation(Modulation, False).base() )
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: ( digital.constellation_bpsk().base() if (mod_type == "PSK" and Modulation == 2) else digital.constellation_qpsk().base() if (mod_type == "PSK" and Modulation == 4) else digital.constellation_8psk().base() if (mod_type == "PSK" and Modulation == 8) else digital.qam_constellation(Modulation, False).base() )
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: Modulation if mod_type == "PSK" else 1
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: Modulation if mod_type == "PSK" else 1
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import json
      from time import time, sleep
      import threading

      CONTROL_FILE = "/home/georgia/Desktop/SDR/control/phy_control.txt"

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Packet Generator Block - generates PDUs with random bytes"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='packet generator',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_in(pmt.intern('trigger'))
              self.set_msg_handler(pmt.intern('trigger'), self.handle_msg)

              self.message_port_register_out(pmt.intern('out')) # packets
              self.message_port_register_out(pmt.intern('metrics')) # telemetry
             
              self.packet_id = 0
              self.running = True
              self.sender_thread = threading.Thread(target=self.run_sender, daemon=True)
              self.sender_thread.start()

          def read_packet_rate(self):
              try:
                  with open(CONTROL_FILE, "r") as f:
                      for line in f:
                          if line.startswith("rate="):
                              return max(0, int(line.strip().split("=", 1)[1]))
              except Exception:
                  pass
              return 0

          def send_packet(self):
              length = 256

              data = np.random.randint(0, 256, length, dtype=np.uint8)

              # packet id on the first byte
              data[0] = self.packet_id % 256
              self.packet_id += 1

              pdu = pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(data), data.tolist()))

              # publish pakcet 
              self.message_port_pub(pmt.intern('out'), pdu)

              #publish telemetry
              # self.publish_metrics()

          def run_sender(self):
              while self.running:
                  rate = self.read_packet_rate()
                  if rate > 0:
                      self.send_packet()
                      sleep(1.0 / rate)
                  else:
                      sleep(0.2)

          def handle_msg(self, msg):
              self.send_packet()

          def stop(self):
              self.running = False
              return True

          def publish_metrics(self):
              metrics = {
                  'snr': 12.5,
                  'ber': 0.00003,
                  'rssi': -42.0,
                  # 'packet_id': self.packet_id,
                  # 'noise_voltage': noise_voltage,
                  'timestamp': time()
              }
              print("SENT:", metrics)
              msg = json.dumps(metrics).encode('utf-8')

              # send directly as u8vector (no PDU wrapper )
              u8vec = pmt.init_u8vector(len(msg), list(msg))
              self.message_port_pub(pmt.intern('metrics'), u8vec)
              # msg_list = list(msg) # convert bytes to list of integers
              # pdu = pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(msg_list), msg_list))
              # self.message_port_pub(pmt.intern('metrics'), pdu)
    example_param: '1.0'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport json\nfrom time import time\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\nCONTROL_FILE = \"/home/georgia/Desktop/SDR/control/phy_control.txt\"\n\n# BER comparator\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Compare TX/RX byte streams and publish BER metrics.\"\"\"\n\n    def __init__(self):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='ber_comparator',   # will show up in GRC\n            in_sig=[np.uint8, np.uint8],  # two input streams of bytes\n            out_sig=None\n        )\n\n        # Metrics output\n        self.message_port_register_out(pmt.intern('metrics'))\n\n        # Running totals (lifetime)\n        self.total_bits = 0\n        self.total_bit_errors = 0\n\n        # Windowed BER state\n        self.window_symbols = 0\n        self.window_errors = 0\n        self.WINDOW_SIZE = 1000\n\n        # Controlled BER injection (0.0 .. 1.0 probability per compared symbol).\n        self.ber_inject = 0.0\n        self._last_poll = 0.0\n        self.poll_interval = 0.2\n\n    def _update_ber_inject_from_file(self):\n        now = time()\n        if now - self._last_poll < self.poll_interval:\n            return\n\n        self._last_poll = now\n        try:\n            with open(CONTROL_FILE, \"r\") as f:\n                for line in f:\n                    if line.startswith(\"ber_inject=\"):\n                        value = float(line.split(\"=\", 1)[1].strip())\n                        self.ber_inject = max(0.0, min(value, 1.0))\n                        break\n        except Exception:\n            pass\n\n\n    def work(self, input_items, output_items):\n        # Receive synchronized TX/RX streams.\n        tx = input_items[0]\n        rx = input_items[1]\n        self._update_ber_inject_from_file()\n        # print(\"TX:\", tx[:10])\n        # print(\"RX:\", rx[:10])\n        n = min(len(tx), len(rx))\n        print(\"[BER] work() items:\", n)\n        if n == 0:\n            return 0\n        \n\n        # Compare only the common region if buffers differ in length.\n        tx_view = tx[:n]\n        rx_view = rx[:n]\n\n        if self.ber_inject > 0.0:\n            rx_eval = rx_view.copy()\n            inject_mask = np.random.random(n) < self.ber_inject\n            rx_eval[inject_mask] = np.bitwise_xor(rx_eval[inject_mask], np.uint8(1))\n        else:\n            rx_eval = rx_view\n\n        bit_errors = int(np.sum(tx_view != rx_eval))\n\n        # Update running totals.\n        self.total_bits += n\n        self.total_bit_errors += bit_errors\n\n        print(f\"[BER] chunk errors: {bit_errors}/{n}\")\n        print(f\"[BER] totals: bits={self.total_bits}, errors={self.total_bit_errors}\")\n        # with open(\"/tmp/phy_stats.txt\", \"w\") as f:\n        #     f.write(f\"{self.total_bits},{self.total_bit_errors}\\n\")\n            \n        self.window_symbols += n\n        self.window_errors += bit_errors\n\n        # Publish BER once enough symbols have been collected.\n        if self.window_symbols >= self.WINDOW_SIZE:\n            ber = self.window_errors / self.window_symbols\n            \n            print(\"[BER] window ber:\", ber)\n                \n            # Send metrics as a dictionary\n            metrics = {\n                'ber': ber,\n                'bits': self.total_bits,\n                'errors': self.total_bit_errors,\n                'timestamp': time()\n            }\n\n            msg_json = json.dumps(metrics).encode('utf-8')\n            u8vec = pmt.init_u8vector(len(msg_json), list(msg_json))\n            self.message_port_pub(pmt.intern('metrics'), u8vec)\n\n            # Reset window counters after publishing.\n            self.window_symbols = 0\n            self.window_errors = 0\n            \n        return n\n\n"
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time

      CONTROL_FILE = "/home/georgia/Desktop/SDR/control/phy_control.txt"


      class blk(gr.sync_block):
          """Adds AWGN and frequency offset with runtime control from control file."""

          def __init__(self, noise_voltage=0.0, snr_db=30.0, poll_interval=0.2, sample_rate=100000.0):
              gr.sync_block.__init__(
                  self,
                  name='SNMP Noise Control',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.noise_voltage = float(noise_voltage)
              self.last_noise_voltage = float(noise_voltage)
              self.snr_db = float(snr_db)
              self.last_snr_db = float(snr_db)
              self.freq_offset_hz = 0.0
              self.last_freq_offset_hz = 0.0
              self.sample_rate = max(1.0, float(sample_rate))
              self.phase_inc = 0.0
              self.phase = 0.0
              self.poll_interval = float(poll_interval)
              self._last_poll = 0.0

          def _update_from_file(self):
              now = time.monotonic()
              if now - self._last_poll < self.poll_interval:
                  return

              self._last_poll = now

              try:
                  with open(CONTROL_FILE) as f:
                      for line in f:
                          if line.startswith("snr="):
                              snr_value = float(line.split("=", 1)[1].strip())
                              if snr_value != self.last_snr_db:
                                  self.snr_db = snr_value
                                  self.last_snr_db = snr_value
                          elif line.startswith("noise="):
                              noise_value = float(line.split("=", 1)[1].strip())
                              if noise_value != self.last_noise_voltage:
                                  self.noise_voltage = noise_value
                                  self.last_noise_voltage = noise_value
                          elif line.startswith("freq_offset="):
                              freq_offset = float(line.split("=", 1)[1].strip())
                              if freq_offset != self.last_freq_offset_hz:
                                  self.freq_offset_hz = freq_offset
                                  self.last_freq_offset_hz = freq_offset
                                  self.phase_inc = (2.0 * np.pi * self.freq_offset_hz) / self.sample_rate
              except Exception:
                  pass

          def work(self, input_items, output_items):
              self._update_from_file()

              in0 = input_items[0]
              out = output_items[0]
              n = len(in0)

              if n == 0:
                  return 0

              if self.phase_inc != 0.0:
                  phases = self.phase + self.phase_inc * np.arange(n, dtype=np.float32)
                  rot = np.exp(1j * phases).astype(np.complex64)
                  sig = in0 * rot
                  self.phase = float((phases[-1] + self.phase_inc) % (2.0 * np.pi))
              else:
                  sig = in0

              sigma_snr = 0.0
              if self.snr_db < 80.0:
                  sig_power = float(np.mean(np.abs(sig) ** 2)) if n > 0 else 0.0
                  if sig_power > 0.0:
                      snr_linear = 10.0 ** (self.snr_db / 10.0)
                      if snr_linear > 0.0:
                          noise_power = sig_power / snr_linear
                          sigma_snr = float(np.sqrt(noise_power / 2.0))

              sigma_noise = max(0.0, float(self.noise_voltage)) / np.sqrt(2.0)
              sigma = float(np.sqrt((sigma_snr ** 2) + (sigma_noise ** 2)))

              if sigma <= 0.0:
                  out[:] = sig
                  return len(out)
              
              noise_real = np.random.normal(0.0, sigma, len(in0)).astype(np.float32)
              noise_imag = np.random.normal(0.0, sigma, len(in0)).astype(np.float32)

              out[:] = sig + noise_real + 1j * noise_imag
              return len(out)
    noise_voltage: '0.0'
    poll_interval: '0.2'
    sample_rate: samp_rate
    snr_db: '30.0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:9555
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:5558
    bind: 'False'
    timeout: '100'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, epy_block_0, trigger]
- [blocks_repack_bits_bb_0, '0', blocks_selector_1, '1']
- [blocks_repack_bits_bb_0, '0', digital_diff_encoder_bb_0, '0']
- [blocks_repack_bits_bb_0, '0', epy_block_1, '0']
- [blocks_selector_1, '0', digital_constellation_encoder_bc_0, '0']
- [blocks_selector_1_0, '0', epy_block_1, '1']
- [blocks_throttle2_0, '0', epy_block_3, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_selector_1_0, '1']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_encoder_bc_0, '0', blocks_throttle2_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_selector_1_0, '0']
- [digital_diff_encoder_bb_0, '0', blocks_selector_1, '0']
- [epy_block_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [epy_block_0, out, zeromq_pub_msg_sink_0, in]
- [epy_block_1, metrics, zeromq_push_msg_sink_0_0, in]
- [epy_block_3, '0', digital_constellation_decoder_cb_0, '0']
- [epy_block_3, '0', qtgui_const_sink_x_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_repack_bits_bb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
